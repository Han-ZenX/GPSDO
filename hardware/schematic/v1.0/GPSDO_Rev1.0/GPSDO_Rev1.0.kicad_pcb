# Repository Han-ZenX/GPSDO

File README.md:

# 🛰️ GPSDO - GPS disciplined Oscillator (GPS  disciplining frequency standard)

<div align="center">

**A highly integrated, portable and high-precision GPSDO**  
一款高度集成、便携式、高精度的 GPS discipling frequency standard

</div>

---

## 📖 概述 (Overview)

GPSDO (GPS Disciplined Oscillator) 是一种利用 GPS 卫星信号来校准高精度晶振频率的设备。本项目采用模块化设计，支持长期持续迭代，具备：

- ✨ **高稳定性**：PPB 级频率精度
- 🔧 **便携设计**：低功耗、一体化结构
- 🚀 **易于扩展**：分层架构，支持功能升级
- 💻 **开放源码**：完整固件 + 硬件设计开源

---

## 🎯 主要特性

| 特性 | 说明 |
|------|------|
| **精度** | PPB（十亿分之一）级别的频率稳定度 |
| **温度补偿** | 内置高精度温度传感器，实时补偿 |
| **数据记录**：支持 SD 卡存储历史数据 |
| **通信接口**：UART/SPI/I2C 多种通信方式 |
| **显示模块**：可扩展 OLED/LCD 显示屏 |
| **电源管理**：宽电压输入，锂电池供电 |
| **外壳设计**：可 3D 打印或 CNC 加工 |

---

## 🏗️ 系统架构

项目采用 **Monorepo + 四层分层架构**，各层级职责清晰：

```
GPSDO/
├── firmware/          # 嵌入式固件 (STM32G431KBU6)
│   ├── src/
│   │   ├── app/       # 应用层：业务逻辑、算法、UI
│   │   ├── hal/       # 硬件抽象层：GPIO、时钟、中断
│   │   ├── drivers/   # 驱动层：SPI、I2C、UART 等外设
│   │   └── services/  # 服务层：通信协议、数据存储
│   └── boards/        # 板级配置 (不同硬件版本)
│
├── hardware/          # KiCad 硬件设计
│   ├── schematic/v1.0/# 原理图
│   ├── pcb/v1.0/      # PCB 布局
│   ├── bom/           # BOM 物料清单
│   └── pinout/        # 引脚分配表
│
├── docs/              # 项目文档
│   ├── architecture/  # 系统架构说明
│   ├── user-guide/    # 用户使用手册
│   └── api/           # API 接口文档
│
├── software/          # 配套软件（开发中）
│   ├── desktop/       # PC 桌面应用
│   └── mobile/        # 移动端 App
│
├── tests/             # 测试套件
├── tools/             # 构建脚本与工具
└── ci/                # CI/CD 流水线配置
```

### 分层架构优势

| 层级 | 职责 | 独立性 |
|------|------|--------|
| **Application** | 业务逻辑、状态机 | 更换 MCU 零修改 |
| **HAL** | GPIO、时钟、中断 | 换 MCU 时整体替换 |
| **Drivers** | SPI/I2C/UART 通信 | 随外设更换更新 |
| **Services** | 通信、存储、OTA | 可独立升级 |

👉 **核心原则**：业务逻辑不直接访问寄存器，确保代码可移植性。

---

## 🛠️ 硬件规格 (Hardware Specs)

### 主控芯片
- **MCU**: STM32G431KBU6 (Cortex-M4F, 170MHz)
- **Flash**: 1MB
- **RAM**: 112KB

### GPS 模块
- **芯片**: SKG123NT
- **通道数**: 72 通道
- **定位精度**: 水平 < 2.5m CEP

### ADC 采样
- **芯片**: ADS1115 / ADS1258
- **分辨率**: 16/24-bit
- **采样率**: 上行至 8SPS

### 辅助传感器
- **温度传感器**: TMP117 (-40~+125°C, ±0.1°C)
- **RTC**: PCF8563 (带电池备份)

### 接口
- UART: 调试串口 / 通信接口
- SPI: ADC / 显示屏
- I2C: 传感器 / EEPROM
- GPIO: LED / 按键 / 扩展

---

## 📦 构建指南 (Build Instructions)

### 环境要求

- CMake ≥ 3.16
- ARM GCC Toolchain (`arm-none-eabi-gcc`)
- Python 3.8+ (用于自动化脚本)

### 快速开始

#### Windows (PowerShell)
```powershell
# Debug 构建 (默认板级)
cd firmware
cmake -B build -DBOARD=default
cmake --build build

# Release 构建
cmake -B build -DBOARD=default -DCMAKE_BUILD_TYPE=Release
cmake --build build
```

#### Linux/macOS
```bash
# 使用自动化脚本 (推荐)
python tools/scripts/build.py --board=default

# 或使用 CMake 命令
cmake -B build -DBOARD=default && cmake --build build
```

### 多板级支持

添加新的硬件版本：
```bash
# 复制默认板级配置
cp -r firmware/boards/default firmware/boards/v2.0

# 编辑引脚映射
nano firmware/boards/v2.0/board_config.h

# 编译新版本
cmake -B build -DBOARD=v2.0
```

---

## 🧪 测试运行

### 单元测试 (Host-based)
```bash
# 在 PC 上运行纯软件测试
python tools/scripts/build.py --test unit
```

### 集成测试
```bash
# 模块间交互测试
python tools/scripts/build.py --test integration
```

### HWT (Hardware-in-the-Loop)
```bash
# 硬件在环测试
python tools/scripts/build.py --test hwt
```

---

## 📂 目录结构详解

### `firmware/src/`
| 目录 | 说明 |
|------|------|
| `app/` | 应用层：GPS 数据处理、频偏计算、状态机 |
| `hal/` | HAL 层：STM32 寄存器操作封装 |
| `drivers/` | 驱动层：ADS1258、u-blox、TMP117 等 |
| `services/` | 服务层：NMEA 解析、Flash 日志、UART 协议 |

### `hardware/schematic/v1.0/`
KiCad 原理图工程文件：
- `GPSDO.kicad_sch` - 原理图
- `GPSDO.kicad_pcb` - PCB 布局
- `fp-lib-table` - 封装库

---

## 🔌 通信协议 (Communication Protocol)

### UART 协议格式
```
波特率：115200
数据位：8
停止位：1
校验位：无
流控：无
```

### 指令集示例
```text
AT+GPS?       → 查询 GPS 状态
AT+TEMP?      → 读取温度值
AT+ALIGN      → 手动校准
AT+LOG START  → 开始记录数据
AT+LOG STOP   → 停止记录
```

详细协议文档：`docs/api/communication.md`

---

## 🚀 开发路线图

| 阶段 | 计划 | 状态 |
|------|------|------|
| **v1.0** | 基础版 - 核心功能实现 | ✅ 完成 |
| **v1.1** | 优化算法 - 提升精度 | 🔄 进行中 |
| **v1.2** | 增加 LCD 显示 | 📋 规划中 |
| **v2.0** | 蓝牙/Wi-Fi 远程监控 | 📋 未来计划 |
| **v3.0** | 云端数据同步 | 📋 概念验证 |

---

## 📄 许可证

本项目采用 **[MIT License](LICENSE)** 开源协议

允许：
- ✅ 自由商用
- ✅ 修改代码
- ✅ 分发源码
- ✅ 私有修改

要求：
- ⚠️ 保留版权声明
- ⚠️ 注明原始作者

---

## 👥 贡献指南

欢迎提交 Issue 和 Pull Request！

### 开发流程
1. Fork 本仓库
2. 创建特性分支 (`git checkout -b feature/amazing-feature`)
3. 提交更改 (`git commit -m 'Add some amazing feature'`)
4. 推送到分支 (`git push origin feature/amazing-feature`)
5. 开启 Pull Request

### 编码规范
- C 代码遵循 [Google C Style Guide](https://google.github.io/styleguide/cguide.html)
- 函数注释使用 Doxygen 格式
- 提交信息符合 [Conventional Commits](https://www.conventionalcommits.org/)

---

## 📞 联系方式

- **作者**: Han-ZenX
- **项目主页**: https://github.com/Han-ZenX/GPSDO
- **问题反馈**: [GitHub Issues](https://github.com/Han-ZenX/GPSDO/issues)

---

## 🙏 致谢

本项目参考了以下优秀开源项目：

- **ESP-IDF** - 组件化架构设计
- **Zephyr RTOS** - 板级抽象层模式
- **FreeRTOS** - 任务调度机制
- **RIOT-OS** - 驱动分层设计

---

## 📊 统计信息

```
语言分布:
├── C         54.8%
├── CMake     21.6%
└── Python    23.6%
```

---

<div align="center">

**Made with ❤️ for Precision Timing**

⭐ Star 本仓库以支持项目开发！

</div>

## KiCad design hardware/schematic/v1.0/GPSDO_Rev1.0/GPSDO_Rev1.0.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad

Connections:
GND: H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1); also elsewhere on the board

Notes on the sheet:
HOLE

Parts:
C46, C48: 100nF; C_0402_1005Metric
C47, C49: 4.7uF; C_0603_1608Metric
D6, D9: TPD1E10B06DPYR; Manufacturer Part TPD1E10B06DPYR; LCSC C48260
J1, J4: Conn_Coaxial; SMA_Amphenol_132289_EdgeMount
R20, R47: 49.9; R_0805_2012Metric
R42, R46: 10K; R_0402_1005Metric
U13: ISL55110IRZ-T; Manufacturer Part ISL55110IRZ-T; LCSC C2680304

Connections:
+3.3V: C46.1, C47.1, U13.1 (VDD); also elsewhere on the board
+5V2: C48.1, C49.1, U13.10 (VH); also elsewhere on the board
/EXT/10MHZ_OUT: R42.1, U13.5 (IN-A); also elsewhere on the board
/EXT/PULSE_OUT: R46.2, U13.4 (IN-B); also elsewhere on the board
GND: C46.2, C47.2, C48.2, C49.2, D6.2, D9.2, J1.2 (Ext), J4.2 (Ext), R42.2, R46.1, U13.2 (ENABLE#), U13.3 (PD), U13.11 (GND), U13.17 (EP); also elsewhere on the board
unnamed: D6.1, J1.1 (In), R20.2
unnamed: D9.1, J4.1 (In), R47.2
unnamed: R20.1, U13.9 (OA)
unnamed: R47.1, U13.12 (OB)

Notes on the sheet:
10 MHz Outputs
Pulse Outputs

Parts:
C1, C4, C5, C11, C16, C18, C22, C24, C26: 100nF; C_0402_1005Metric
C2, C19, C56, C58: 10uF; C_0603_1608Metric
C3, C17, C20, C57: 1uF; C_0603_1608Metric
C21: 2.2uF; C_0603_1608Metric
FB3, FB4, FB5: 100R; L_0603_1608Metric
FB7: 600R; L_0603_1608Metric
R4: 0; R_0402_1005Metric
R5: 0; R_0805_2012Metric
R6, R7, R36: 0; R_0603_1608Metric
R12, R15, R16: 4K7; R_0402_1005Metric
R13, R41: 1K; R_0402_1005Metric
R17: 100R; R_0603_1608Metric
R18: 15K; R_0603_1608Metric
R19: 8.2K; R_0603_1608Metric
R28: 10R; R_0603_1608Metric
R29: 0R; R_0603_1608Metric
R35, R39, R40: 100K; R_0402_1005Metric
R37: 0; R_0402_1005Metric; not fitted
RF2: KH-IPEX-K501-29; Manufacturer Part KH-IPEX-K501-29; LCSC C411563
TP1: Volt TestPoint; TestPoint_Pad_D1.0mm
TP2: TestPoint; TestPoint_Pad_D1.0mm
U2: LMK1C1103PWR; Manufacturer Part LMK1C1103PWR; LCSC C2873274
U3: TMP117AIDRVR; Manufacturer Part TMP117AIDRVR; LCSC C699536
U5: OCXO_20x20mm; not fitted
U7: OCXO_25.4x25.4mm; DOPFITKR2-10M
U8: REF5040; Manufacturer Part REF5040AIDR; LCSC C46274
U9: OPA388IDR; Manufacturer Part OPA388IDR; LCSC C154118
U10: SN74LVC1T45DBVR; Manufacturer Part SN74LVC1T45DBVR; LCSC C7843

Connections:
+3.3V: C16.1, C22.1, FB3.2, R12.1, R15.1, R16.1, U3.5 (V+), U10.1 (VCCA), U10.5 (DIR); also elsewhere on the board
+5V: FB7.2, R28.2; also elsewhere on the board
/EXT/10MHZ_OUT: U2.3 (Y0); also elsewhere on the board
/MCU/10MHZ_MCU: R6.2; also elsewhere on the board
/MCU/10MHZ_TDC: R7.2; also elsewhere on the board
/MCU/PWM: R35.1, U10.3 (A); also elsewhere on the board
/MCU/TMP_SCL: R16.2, U3.1 (SCL); also elsewhere on the board
/MCU/TMP_SDA: R12.2, U3.6 (SDA); also elsewhere on the board
/MCU/VCTL: C26.1, R41.1; also elsewhere on the board
/OCXO/OCXO_MON: C5.2, R13.1
/OCXO/OCXO_MON_RF: C5.1, RF2.4 (SIG)
/OCXO/OCXO_OUT: R36.1, R37.1, U2.1 (CLKIN)
/OCXO/VCTRL: C19.1, R17.2, R39.2, U5.4 (VCTRL/NC), U7.3 (VCTRL)
GND: C1.1, C2.1, C3.2, C4.2, C11.1, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, C24.2, C26.2, C56.2, C57.2, C58.2, R35.2, R37.2, R40.1, RF2.1 (GND), RF2.2 (GND), RF2.3 (GND), TP2.1 (1_1), U2.4 (GND), U3.2 (GND), U3.4 (ADD0), U3.7 (EP), U5.3 (GND), U7.2 (GND), U8.4 (GND), U9.4 (V-), U10.2 (GND); also elsewhere on the board
unnamed: C21.1, R18.1, R19.2
unnamed: R39.1, R40.2, R41.2
unnamed: C3.1, C4.1, FB3.1, U2.2 (1G), U2.6 (VDD)
unnamed: R6.1, U2.8 (Y1)
unnamed: R7.1, U2.5 (Y2)
unnamed: R15.2, U3.3 (ALERT)
unnamed: R4.1, U5.2 (RF)
unnamed: R5.2, U5.1 (VCC)
unnamed: C57.1, U8.5 (TRIM/NR)
unnamed: C11.2, C56.1, R28.1, U8.2 (VIN)
unnamed: C58.1, R29.1, U8.6 (VOUT)
unnamed: C20.1, R18.2, U9.3 (+IN)
unnamed: C21.2, R17.1, U9.2 (-IN), U9.6 (OUT)
unnamed: C17.1, C18.1, FB7.1, U9.7 (V+)
unnamed: R19.1, U10.4 (B)
OCXO_RF: R4.2, R13.2, R36.2, U7.1 (RF)
OCXO_VCC: C1.2, C2.2, FB4.1, FB4.2, FB5.1, FB5.2, R5.1, TP1.1 (1_1), U7.5 (VCC); also elsewhere on the board
VREF: C24.1, R29.2, U10.6 (VCCB)

Notes on the sheet:
Active Low-pass Filter for Tuning Voltage
Fanout Buffer
Passive LPF to compensate attenuation reversal of active LPF.
OCXO 25.4x25.4mm
OCXO 20x20mm
50 OHM TRACE
OCXO 二选一
Temperature Sensor
VREF

Parts:
C6, C8: 1uF; C_0603_1608Metric
C7: 100nF; C_0402_1005Metric
FB8: 100R; L_0603_1608Metric
L1: 33nH; L_0402_1005Metric
R1: 0; R_0402_1005Metric
R2, R3: 33; R_0402_1005Metric
R8: 100K; R_0402_1005Metric
R9: 470; R_0402_1005Metric
RF1: KH-IPEX-K501-29; Manufacturer Part KH-IPEX-K501-29; LCSC C411563
U6: NEO-M8T-0; Manufacturer Part NEO-M8T-0; LCSC C6330770

Connections:
+3.3V: FB8.1, R9.2; also elsewhere on the board
/GNSS/GNSS_UART_RXD: R3.2; also elsewhere on the board
/GNSS/GNSS_UART_TXD: R2.1; also elsewhere on the board
/GNSS/PULSE_GNSS: R1.2; also elsewhere on the board
/GNSS/VCC_RF: L1.2, U6.9 (VCC_RF)
GND: C6.2, C7.2, C8.2, R8.1, RF1.1 (GND), RF1.2 (GND), RF1.3 (GND), U6.10 (GND), U6.12 (GND), U6.13 (GND), U6.24 (GND); also elsewhere on the board
unnamed: L1.1, RF1.4 (SIG), U6.11 (RF_IN)
unnamed: R3.1, U6.21 (RXD/SPIMOSI)
unnamed: R1.1, U6.3 (TIMEPULSE)
unnamed: R2.2, U6.20 (TXD/SPIMISO)
unnamed: C6.1, C7.1, FB8.2, U6.23 (VCC)
unnamed: R8.2, U6.7 (VDD_USB)
unnamed: C8.1, R9.1, U6.22 (V_BCKP)

Notes on the sheet:
50 OHM TRACE
SKYLAB SKG123NT
u-blox NEO-M8T
u-blox NEO-F10T
SKYLAB SKG123N

Parts:
C9, C10, C28: 1uF; C_0603_1608Metric
C12, C13, C14, C15, C27, C32, C33, C42: 100nF; C_0402_1005Metric
D3: GREEN; LED_0603_1608Metric
D4: YELLOW; LED_0603_1608Metric
D5: RED; LED_0603_1608Metric
FB1, FB2, FB6: 100R; L_0603_1608Metric
J3: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
JP1: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R10: 100K; R_0402_1005Metric
R11, R14: 5.1K; R_0402_1005Metric
R21, R24, R25: 2.2K; R_0402_1005Metric
R38: 0; R_0402_1005Metric
R48: 10K; R_0402_1005Metric
U1: TDC7200PWR; Manufacturer Part TDC7200PWR; LCSC C2653139
U11: CH340E; Manufacturer Part CH340E; LCSC C99652
U15: STM32G431CBU6; Manufacturer Part STM32G431CBU6; LCSC C529356
USB1: TYPE-C_16PIN_2MD_073; Manufacturer Part TYPE-C 16PIN 2MD(073); LCSC C2765186

Connections:
+3.3V: FB1.2, FB2.2, FB6.2; also elsewhere on the board
/EXT/PULSE_OUT: R38.1; also elsewhere on the board
/GNSS/GNSS_UART_RXD: U15.10 (PA2); also elsewhere on the board
/GNSS/GNSS_UART_TXD: U15.11 (PA3); also elsewhere on the board
/GNSS/PULSE_GNSS: U1.3 (START), U15.24 (PB11); also elsewhere on the board
/MCU/10MHZ_MCU: U15.5 (PF0-OSC_IN); also elsewhere on the board
/MCU/10MHZ_TDC: JP1.1 (A), U1.5 (CLOCK); also elsewhere on the board
/MCU/BOOST_EN: U15.17 (PB0); also elsewhere on the board
/MCU/LED_GREEN: R21.2, U15.39 (PC10)
/MCU/LED_RED: R25.2, U15.41 (PB3)
/MCU/LED_YELLOW: R24.2, U15.40 (PC11)
/MCU/NRST: C42.2, J3.1, U15.7 (PG10-NRST)
/MCU/PWM: U15.34 (PA12); also elsewhere on the board
/MCU/SWCLK: J3.3, U15.37 (PA14)
/MCU/SWDIO: J3.4, U15.36 (PA13)
/MCU/TDC_ENABLE: U1.1 (ENABLE), U15.30 (PA8)
/MCU/TDC_SPI1_MISO: U1.9 (DOUT), U15.14 (PA6)
/MCU/TDC_SPI1_MOSI: U1.10 (DIN), U15.15 (PA7)
/MCU/TDC_SPI1_NSS: U1.11 (CSB), U15.12 (PA4)
/MCU/TDC_SPI1_SCK: U1.12 (SCLK), U15.13 (PA5)
/MCU/TMP_SCL: U15.38 (PA15); also elsewhere on the board
/MCU/TMP_SDA: U15.45 (PB7); also elsewhere on the board
/MCU/USART1_RX: U11.8 (TXD), U15.32 (PA10)
/MCU/USART1_TX: U11.9 (RXD), U15.31 (PA9)
/MCU/USB_D+: U11.1 (UD+), USB1.A6 (Dp1), USB1.B6 (Dp2)
/MCU/USB_D-: U11.2 (UD-), USB1.A7 (Dn1), USB1.B7 (Dn2)
/MCU/VBAT: C13.1, C14.1, C15.1, C32.1, C33.1, FB1.1, U15.1 (VBAT), U15.20 (VREF+), U15.21 (VDDA), U15.23 (VDD), U15.35 (VDD), U15.48 (VDD)
/MCU/VCTL: U15.9 (PA1); also elsewhere on the board
GND: C9.2, C10.2, C12.2, C13.2, C14.2, C15.2, C27.2, C28.2, C32.2, C33.2, C42.1, D3.1 (K), D4.1 (K), D5.1 (K), J3.2, R11.1, R14.1, R48.2, U1.7 (GND), U11.3 (GND), U15.49 (VSS), USB1.13 (EH), USB1.14 (EH), USB1.A1B12 (GND), USB1.B1A12 (GND); also elsewhere on the board
unnamed: D3.2 (A), R21.1
unnamed: D4.2 (A), R24.1
unnamed: D5.2 (A), R25.1
unnamed: JP1.2 (B), U1.4 (STOP)
unnamed: R10.2, U1.8 (INTB)
unnamed: C10.1, C12.1, FB2.1, R10.1, U1.14 (VDD)
unnamed: C9.1, U1.13 (VREG)
unnamed: C27.1, C28.1, FB6.1, U11.7 (VCC), U11.10 (V3)
unnamed: R48.1, U15.46 (PB8-BOOT0)
unnamed: R38.2, U15.22 (PB10)
unnamed: R11.2, USB1.A5 (CC1)
unnamed: R14.2, USB1.B5 (CC2)
VBUS: USB1.A4B9 (VBUS), USB1.B4A9 (VBUS); also elsewhere on the board

Notes on the sheet:
SWD Connector
Time-to-Digital Converter
USB Connector
ADC1_IN2
USART2_RX
TIM2_CH4
USART2_TX
TIM4_CH2
Microcontroller
32bit TIM
TIM2_CH3

Parts:
C23: TAJB107M010RNJ; Manufacturer Part TAJB107M010RNJ; LCSC C7196
C25: 10uF; C_0603_1608Metric
C34, C37, C38, C41: 22uF; C_0805_2012Metric
C35, C39, C43, C73: 100nF; C_0402_1005Metric
C36, C40: 10nF; C_0402_1005Metric
C68, C69: 1uF / 16V; C_0603_1608Metric
C70: 100nF / 16V; C_0402_1005Metric
C71, C74, C75: 22uF / 10V; C_0805_2012Metric
C72: 10uF / 10V; C_0603_1608Metric
CN1: LAIL-PHC2_54-2P-01-XH-L; Manufacturer Part LAIL-PHC2.54-2P-01-XH-L; LCSC C54905973
D1, D2, D8: LED; LED_0603_1608Metric
F1: BSMD1206C-1300T; Manufacturer Part BSMD1206C-1300T; LCSC C41367225
L2: 1uH / DFE201610P; L_Murata_DFE201610P
R22: 0; R_0805_2012Metric
R23: 0; R_0805_2012Metric; not fitted
R26, R32: 12.1K; R_0402_1005Metric
R27, R31: 100K; R_0402_1005Metric
R30, R33: 3.87K; R_0402_1005Metric
R34, R53: 2.2K; R_0402_1005Metric
R43: 30.1K 1%; R_0402_1005Metric
R44: 10K 1%; R_0402_1005Metric
R45, R49: 1K; R_0402_1005Metric
R50: 10K; R_0402_1005Metric
R51: 77.4K 0.1%; R_0402_1005Metric
R52: 10K 0.1%; R_0402_1005Metric
U4: TPS61023DRLR; Manufacturer Part TPS61023DRLR; LCSC C919459
U14, U16: TPS7A5201RPSR; Manufacturer Part TPS7A5201RPSR; LCSC C2876777
U18: TPS2116DRLR; SOT-583-8

Connections:
3.3V_OCXO: C40.1, C41.1, R23.1, R31.1, R32.1, U16.10 (OUT), U16.11 (OUT)
+3.3V: C36.1, C37.1, C72.1, C73.1, L2.1, R26.1, R27.1, R53.1, U4.3 (VIN), U14.10 (OUT), U14.11 (OUT); also elsewhere on the board
+5V: C25.1, C34.1, C38.1, C43.1, C70.1, C71.1, R22.2, R45.1, U14.1 (IN), U14.2 (IN), U14.3 (EN), U16.1 (IN), U16.2 (IN), U16.3 (EN), U18.2 (VOUT), U18.7 (VOUT); also elsewhere on the board
+5V2: C74.1, C75.1, R51.1, U4.6 (VOUT); also elsewhere on the board
/MCU/BOOST_EN: R49.1; also elsewhere on the board
/POWER/+5V_IN: CN1.1, F1.1
/POWER/BOOST_FB: R51.2, R52.1, U4.1 (FB)
/POWER/EXT_5V: C68.1, F1.2, R43.1, U18.3 (VIN1), U18.5 (MODE)
/POWER/LDO_3V3_FB: C36.2, R26.2, R30.1, U14.9 (FB)
/POWER/LDO_3V3_NR: C35.1, U14.4 (NR/SS)
/POWER/LDO_OCXO_FB: C40.2, R32.2, R33.1, U16.9 (FB)
/POWER/LDO_OCXO_NR: C39.1, U16.4 (NR/SS)
/POWER/LDO_OCXO_PG: R31.2, U16.8 (PG)
/POWER/MUX_PR1: R43.2, R44.1, U18.4 (PR1)
GND: C23.2, C25.2, C34.2, C35.2, C37.2, C38.2, C39.2, C41.2, C43.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, CN1.2, D1.1 (K), D2.1 (K), D8.1 (K), R30.2, R33.2, R44.2, R50.2, R52.2, U4.4 (GND), U14.5 (BIAS), U14.6 (GND), U14.7 (GND), U14.12 (GND), U16.5 (BIAS), U16.6 (GND), U16.7 (GND), U16.12 (GND), U18.1 (GND); also elsewhere on the board
unnamed: D1.2 (A), R53.2
unnamed: D2.2 (A), R34.1
unnamed: D8.2 (A), R45.2
unnamed: R49.2, R50.1, U4.2 (EN)
unnamed: L2.2, U4.5 (SW)
unnamed: R27.2, U14.8 (PG)
OCXO_VCC: C23.1, R22.1, R23.2, R34.2; also elsewhere on the board
VBUS: C69.1, U18.6 (VIN2); also elsewhere on the board

Notes on the sheet:
U4 TPS7A52 5V -> 3.3V 仅 3.3V OCXO 时装配
CC resistors alone do not authorize high-current draw from a PC.
Check 5V dip on source change under maximum load.
EN: PB0; LOW during MCU reset
0.595 x (1 + 77.4K/10K) = 5.200V
USB source must cover OCXO warm-up + full board load.
Target 200mA; check ripple / startup
PR1 threshold: 4.01V typ. (IC reference +/-8%; not precision UVLO).
VIN1: EXT_5V after F1. VIN2: USB VBUS. MODE -> VIN1.
5V source selection: CN1 (priority) / USB VBUS -> +5V
No over-current limit in U18; upstream source protection required.
U3 TPS7A52 5V -> 3.3V 给整体供电
装 R19 = 5V OCXO 直供 / 装 R20 = 3.3V OCXO 经 U4 稳压
Inputs: regulated 5V only (max 5.5V). Total mux current <= 2.5A.
OCXO 供电选配 (二者互斥, 严禁同装):
3.3V -> 5.2V / ISL55110 VH

Board: 4 copper layers, 157 parts (0 on the bottom side), 95 nets, no tracks yet.

Notices in the files:
README.md:
License: MIT
